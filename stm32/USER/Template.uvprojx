# Keil uVision project Template.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 oTime=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD
  c misc: -D__weak="__attribute__((weak))" -D__packed="__attribute__((__packed__))" -D__NOINLINE="__attribute__ ( (noinline) )"--locale=english
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\HARDWARE;..\SYSTEM\bsp;..\HARDWARE\usart1;..\HARDWARE\usart2;..\HARDWARE\usart3;..\CORE\motor;..\CORE\pid;..\HARDWARE\gpio;..\HARDWARE\timer1;..\HARDWARE\timer2;..\HARDWARE\timer3;..\CORE\gyro;..\CORE\pos;..\CORE\event;..\CORE\attitude;..\CORE\task
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: startup_stm32f10x_md.s
  group USER
    ./: main.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/bsp/: bsp.c
  group HARDWARE
    ../HARDWARE/usart1/: usart1.c
    ../HARDWARE/usart2/: usart2.c
    ../HARDWARE/usart3/: usart3.c
    ../HARDWARE/gpio/: gpio.c
    ../HARDWARE/timer1/: timer1.c
    ../HARDWARE/timer2/: timer2.c
    ../HARDWARE/timer3/: timer3.c
  group CORE
    ../CORE/pos/: pos.c
    ../CORE/gyro/: gyro.c
    ../CORE/pid/: pid.c
    ../CORE/attitude/: attitude.c
    ../CORE/motor/: motor.c
    ../CORE/event/: event.c
    ../CORE/task/: task.c
  group README
    ../: README
